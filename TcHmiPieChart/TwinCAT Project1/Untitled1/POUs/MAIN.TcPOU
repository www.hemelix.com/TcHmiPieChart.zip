PROGRAM MAIN
VAR
italy : INT := 55;
france : INT := 49;
spain : INT := 44;
usa : INT := 24;
argentina : INT := 15;
END_VAR

;

END_PROGRAM
